Commit message: Get images from PyBullet

File: multi_goal/envs/assets/little_ball.urdf (robot description, URDF)
Before this commit: robot urdf_robot, 1 links, 0 joints
Links:
- link baseLink: geometry collision sphere radius=0.3; visual sphere radius=0.3
