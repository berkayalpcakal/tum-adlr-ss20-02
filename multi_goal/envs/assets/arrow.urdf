Commit message: PyBullet Labyrinth includes agent velocity

File: multi_goal/envs/assets/arrow.urdf (robot description, URDF)
Before this commit: robot myfirst, 3 links, 2 joints
Links:
- link shaft: mass None -> 0.5
- link tip: mass None -> 0.5
